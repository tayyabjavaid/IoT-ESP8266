# Keil uVision project master_iot_controller.uvprojx, settings and files
target IOT_Controller_Discovery (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: master_iot_controller +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\AT\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Drivers
    ./: usart_driver.c usart_driver.h
  group AT
    ./AT/src/: at_layer.c lexer.c urc_parse.c
  group Src
    ./: main.c
software components: CMSIS:CORE 5.1.2, Device:STM32Cube Framework:Classic 1.7.6, Device:STM32Cube HAL:Common 1.7.6, Device:STM32Cube HAL:Cortex 1.7.6, Device:STM32Cube HAL:DMA 1.7.6, Device:STM32Cube HAL:GPIO 1.7.6, Device:STM32Cube HAL:PWR 1.7.6, Device:STM32Cube HAL:RCC 1.7.6, Device:STM32Cube HAL:UART 1.7.6, Device:STM32Cube HAL:USART 1.7.6, Device:Startup 2.6.3
